options:
  parameters:
    author: Elies, après des larmes de sang
    generate_options: qt_gui
    id: dmr_transceiver
    output_language: python
    title: dmr_transceiver
  states: {}

blocks:
- name: center_freq_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: center_freq_rx
    start: 420.0e6
    step: '1'
    stop: 450.0e6
    value: 433.57446e6
  states: {}
- name: center_freq_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    label: center_freq_tx
    start: 425e6
    step: 1e3
    stop: 445e6
    value: '433575000'
  states: {}
- name: decim_rate
  id: variable
  parameters:
    value: int(int(samp_rate/decim_xlating)/math.gcd(int(samp_rate/decim_xlating),int(target_samp_rate)))
  states: {}
- name: decim_xlating
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 1
    label: freq_dev
    start: '500'
    step: '1'
    stop: '200000'
    value: '648'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: gain
    rangeType: int
    start: '-12'
    step: '1'
    stop: '64'
    value: '40'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '24000.0'
  states: {}
- name: interp_rate
  id: variable
  parameters:
    value: int(int(target_samp_rate)/math.gcd(int(samp_rate/decim_xlating),int(target_samp_rate)))
  states: {}
- name: low_pass_filter_taps_tx_resampler
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '10000'
    gain: sps
    samp_rate: samp_rate*3
    width: '3000'
    win: window.WIN_BLACKMAN
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: rx_port
  id: variable
  parameters:
    value: '52052'
  states: {}
- name: samp_per_symb
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '125.0'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: if_samp_rate / samples_per_symbol
  states: {}
- name: target_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.2'
    gain: '5'
    ntaps: 25*samples_per_symbol
    samp_rate: if_samp_rate
    sym_rate: symbol_rate
  states: {}
- name: xlating_bw
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: xlating_low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: xlating_bw/2
    gain: '1.0'
    samp_rate: samp_rate
    width: xlating_transition_bw
    win: window.WIN_HAMMING
  states: {}
- name: xlating_transition_bw
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      0.339292 -> for real DMR
      2 * math.pi * freq_dev / (if_samp_rate * 0.5)
    maxoutbuf: '8192'
    sensitivity: 2 * math.pi * freq_dev / (if_samp_rate * 0.5)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Me demandez pourquoi cette valeur, mais ça marche (cf world wide web)
    gain: '1.6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    maxoutbuf: '8192'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int((len(low_pass_filter_taps_tx_resampler) - 1) / 2)
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/out
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: pour le type float into short en gros, magie noire gqrx je cherche pas à comprendre là
    scale: '32767'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[gr.tag_utils.python_to_tag({''offset'': 0, ''key'': pmt.intern("tx_sob"), ''value'': pmt.PMT_T, ''srcid'': pmt.intern("src")}), gr.tag_utils.python_to_tag({''offset'': 150, ''key'': pmt.intern("tx_eob"), ''value'': pmt.PMT_T, ''srcid'': pmt.intern("src")})]'
    type: float
    vector: '[0.5, 1.0, -1.5] * 50 + [0.0] * 40'
  states: {state: disabled}
- name: dmr_burst_source_0
  id: dmr_burst_source
  parameters:
    ip: '''127.0.0.1'''
    maxoutbuf: '1024'
    port: '52010'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import socket
      import threading
      from collections import deque

      class blk(gr.sync_block):
          def __init__(self, ip='127.0.0.1', port=52005):
              gr.sync_block.__init__(
                  self,
                  name='Alors ça burst ?',
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self.ip = ip
              self.port = port
              self.map = {0: 0.5, 1: 1.5, 2: -0.5, 3: -1.5}
              
              self.burst_queue = deque() 
              self.current_frame = []
              
              # State counters
              self.mandatory_silence_left = 0
              self.flushing_done_count = 0 # Total zeros sent since the end of the last data frame
              
              self.stop_thread = threading.Event() 
              self.thread = threading.Thread(target=self.socket_listener, daemon=True)
              self.thread.start()

          def socket_listener(self):
              sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              sock.bind((self.ip, self.port))
              sock.settimeout(0.5)
              
              while not self.stop_thread.is_set():
                  try:
                      data, addr = sock.recvfrom(1024)
                      if len(data) >= 35:
                          bytes_array = np.frombuffer(data[:33], dtype=np.uint8)
                          dibits = []
                          for b in bytes_array:
                              dibits.append(self.map[(b >> 6) & 0x03])
                              dibits.append(self.map[(b >> 4) & 0x03])
                              dibits.append(self.map[(b >> 2) & 0x03])
                              dibits.append(self.map[b & 0x03])
                          
                          frame = [0.0, 0.0] + dibits + [0.0, 0.0] # 136 symbols total

                          silence_duration = int.from_bytes(data[33:35], byteorder='big')
                          
                          self.burst_queue.append((frame, silence_duration))
                  except socket.timeout:
                      continue
                  except Exception:
                      break
              sock.close()

          def work(self, input_items, output_items):
              out = output_items[0]
              n_out = len(out)
              produced = 0

              while produced < n_out:

                  if self.current_frame:
                      n_to_send = min(n_out - produced, len(self.current_frame))
                      out[produced:produced + n_to_send] = self.current_frame[:n_to_send]
                      
                      self.current_frame = self.current_frame[n_to_send:]
                      produced += n_to_send
                      
                      if not self.current_frame:
                          self.flushing_done_count = 0
                      continue

                  if self.mandatory_silence_left > 0:
                      n_silence = min(n_out - produced, self.mandatory_silence_left)
                      out[produced:produced + n_silence] = [0.0] * n_silence
                      
                      self.mandatory_silence_left -= n_silence
                      self.flushing_done_count += n_silence
                      produced += n_silence
                      continue

                  if self.burst_queue:
                      frame_data, silence_val = self.burst_queue.popleft()
                      self.current_frame = frame_data
                      self.mandatory_silence_left = silence_val
                      
                      abs_index = self.nitems_written(0) + produced
                      self.add_item_tag(0, abs_index, pmt.intern("tx_sob"), pmt.from_bool(True))
                      self.add_item_tag(0, abs_index + 136, pmt.intern("tx_eob"), pmt.from_bool(True))
                      continue

                  if self.flushing_done_count < 30:
                      n_flush = min(n_out - produced, 30 - self.flushing_done_count)
                      out[produced:produced + n_flush] = [0.0] * n_flush
                      
                      self.flushing_done_count += n_flush
                      produced += n_flush
                      continue

                  if produced > 0:
                      return produced
                  else:
                      return 0

              return produced

          def stop(self):
              self.stop_thread.set()
              self.thread.join(timeout=0.2)
              return True
    ip: '''127.0.0.1'''
    port: '52010'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import socket
      import threading
      from collections import deque

      class blk(gr.sync_block):
          def __init__(self, ip='127.0.0.1', port=52005):
              gr.sync_block.__init__(
                  self,
                  name='Burstidi burstidou burstiditipou',
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self.ip = ip
              self.port = port
              self.map = {0: 0.5, 1: 1.5, 2: -0.5, 3: -1.5}
              
              # les bursts à la queleuleu
              self.burst_queue = deque() 
              self.current_frame = []
              
              # thread parceque sinon delay avec socket, enfin hypthèse (je vais me tirer une balle)
              self.stop_thread = threading.Event() 
              self.thread = threading.Thread(target=self.socket_listener, daemon=True)
              self.thread.start()

              self.flush_needed = 0

          def socket_listener(self):
              sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              sock.bind((self.ip, self.port))
              sock.settimeout(0.5)
              
              while not self.stop_thread.is_set():
                  try:
                      data, addr = sock.recvfrom(1024)
                      if len(data) == 33:
                          bytes_array = np.frombuffer(data, dtype=np.uint8)
                          dibits = []
                          for b in bytes_array:
                              dibits.append(self.map[(b >> 6) & 0x03])
                              dibits.append(self.map[(b >> 4) & 0x03])
                              dibits.append(self.map[(b >> 2) & 0x03])
                              dibits.append(self.map[b & 0x03])
                          
                          # Ici, frame avec preamble + postable pour ne pas avoir de coupure de bits
                          # les tags sont sur le 1er et dernier de ce tableau !
                          frame = [0.0, 0.0] + dibits + [0.0, 0.0]
                          
                          # des 0 pour flush les filtres, sinon on a un pb quelque part ils ont besoin
                          # d'un minimum de data pour se flush. Et puis faut que notre paquet sorte quoi en entier...
                          #frame_with_flush = frame + ([0.0] * 30)
                          # je fais plus, pour pouvoir avoir plus de controle sur le timing...
                          
                          self.burst_queue.append(frame_with_flush)
                  except socket.timeout:
                      continue
                  except Exception:
                      break
              sock.close()

          def stop(self):
              self.stop_thread.set()
              self.thread.join(timeout=0.2)
              return True


          def work(self, input_items, output_items):
              out = output_items[0]
              
              # si pas de frames courrante, regarde si y'en a une
              if not self.current_frame:
                  if not self.burst_queue:
                      return 0 # halllllttttttt, on envoie RIEN si pas de frame (donc le flowgraph meurt)
                  
                  self.current_frame = self.burst_queue.popleft()
                  
                  # calcul index exacts pour tags
                  abs_index = self.nitems_written(0)
                  self.add_item_tag(0, abs_index, pmt.intern("tx_sob"), pmt.from_bool(True))
                  self.add_item_tag(0, abs_index + 136, pmt.intern("tx_eob"), pmt.from_bool(True))
              # on envoie la sauce dans le buffer d'output (toujours pas pigé cette magie noire merci les codes d'example)
              n_output = min(len(out), len(self.current_frame))
              out[:n_output] = self.current_frame[:n_output]
              
              self.current_frame = self.current_frame[n_output:]
              
              return n_output
    ip: '''127.0.0.1'''
    port: '52010'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='DMR Gated TX Controller',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # Initial state is Silence
              self.state = "SILENCE"

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n_input = len(in0)
              n_output = len(out)
              
              # We process as much as we can based on buffer availability
              n_process = min(n_input, n_output)
              
              # Get tags associated with this batch of input samples
              tags = self.get_tags_in_window(0, 0, n_process)

              for i in range(n_process):
                  # Check if any tags start or end a burst at this specific sample
                  for tag in tags:
                      if tag.offset == self.nitems_read(0) + i:
                          tag_name = pmt.symbol_to_string(tag.key)
                          if tag_name == "tx_sob":
                              self.state = "TX"
                          elif tag_name == "tx_eob":
                              self.state = "SILENCE"

                  # State Machine Output
                  if self.state == "TX":
                      # Pass the modulated DMR signal through
                      out[i] = in0[i]
                  else:
                      # Output absolute zero (Radio "Off")
                      out[i] = 0.0001 + 0.00001j

              # Consume and produce the samples
              self.consume(0, n_process)
              return n_process
    maxoutbuf: '8192'
  states: {}
- name: filter_delay_fc_0
  id: filter_delay_fc
  parameters:
    maxoutbuf: '8192'
    taps: tx_rrc_taps
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (1/samp_per_symb,)*samp_per_symb
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-offset'
    decim: decim_xlating
    samp_rate: samp_rate
    taps: xlating_low_pass_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1024'
    port: rx_port
    send_eof: 'True'
    type: short
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: target_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: target_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Frequency Modulated filtered
    size: 2**10
    srate: samp_rate
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Frequency Modulated
    size: 2**10
    srate: samp_rate
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Test
    size: 2**10
    srate: samp_rate
    type: complex
    ymax: '5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: After Selector
    size: 2**10
    srate: samp_rate
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Raw Chunks
    size: 2**10
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_rate
    interp: interp_rate
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samples_per_symbol
    maxoutbuf: '1024'
    taps: tx_rrc_taps
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: int(sps)
    taps: low_pass_filter_taps_tx_resampler
    type: ccc
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import threading
      import time
      from subprocess import Popen


      def callback_dsd():
        Popen("nc -lu 52052 | dsd-fme   -Z -i - -Q ../../../../../../../tmp/out", shell=True)

      def callback_nc():
        Popen("alacritty -e \"bash -c 'nc -lu 52020'\"", shell=True)


      dsd_thread = threading.Thread(target=callback_dsd, daemon=True)
      dsd_thread.start()

      #nc_thread = threading.Thread(target=callback_nc, daemon=True)
      #nc_thread.start()
    section: main_after_init
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq_tx
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {state: disabled}
- name: soapy_limesdr_sink_0_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: center_freq_tx
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq_rx + offset
    gain: '50.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', epy_block_1, '0']
- [analog_frequency_modulator_fc_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_float_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_delay_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_delay_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_float_to_short_0, '0', network_udp_sink_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0_0_2, '0']
- [blocks_vector_source_x_0, '0', rational_resampler_xxx_0_0, '0']
- [dmr_burst_source_0, '0', qtgui_time_sink_x_0_0_2, '0']
- [dmr_burst_source_0, '0', rational_resampler_xxx_0_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0_2, '0']
- [epy_block_0, '0', rational_resampler_xxx_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_2, '0']
- [epy_block_0_0, '0', rational_resampler_xxx_0_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_1, '0', rational_resampler_xxx_1, '0']
- [filter_delay_fc_0, '0', blocks_complex_to_float_0, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_short_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', filter_delay_fc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [rational_resampler_xxx_1, '0', soapy_limesdr_sink_0_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

options:
  parameters:
    author: Elies le plus bô le prô de gnu radiô (ça rime héhé)
    generate_options: qt_gui
    id: dsd_fme_source
    output_language: python
    title: dsd_fme_source
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: center_freq
    start: 433.500e6
    step: '1'
    stop: 433.620e6
    value: 433.57446e6
  states: {}
- name: decim_rate
  id: variable
  parameters:
    value: int(int(samp_rate/decim_xlating)/math.gcd(int(samp_rate/decim_xlating),int(target_samp_rate)))
  states: {}
- name: decim_xlating
  id: variable
  parameters:
    value: '1'
  states: {}
- name: interp_rate
  id: variable
  parameters:
    value: int(int(target_samp_rate)/math.gcd(int(samp_rate/decim_xlating),int(target_samp_rate)))
  states: {}
- name: offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_per_symb
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: xlating_bw
  id: variable
  parameters:
    value: 16e3
  states: {}
- name: xlating_low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: xlating_bw/2
    gain: '1.0'
    samp_rate: samp_rate
    width: xlating_transition_bw
    win: window.WIN_HAMMING
  states: {}
- name: xlating_transition_bw
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.6'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: scale to s16 -> 32767
    scale: '32767'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (1/samp_per_symb,)*samp_per_symb
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-offset'
    decim: decim_xlating
    samp_rate: samp_rate
    taps: xlating_low_pass_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    comment: feed dsd-fme
    header: '0'
    payloadsize: '1024'
    port: '7355'
    send_eof: 'True'
    type: short
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: target_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: target_samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim_rate
    interp: interp_rate
    type: ccc
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq + offset
    gain: '50.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_short_0, '0', network_udp_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_short_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

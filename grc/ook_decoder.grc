options:
  parameters:
    author: Stagiaire deluxe
    generate_options: qt_gui
    id: ook_decoder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: agc_off
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    label: agc_off
    'true': '0'
    type: int
    value: 'True'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: center_freq
    start: 430e6
    step: 1e5
    stop: 440e6
    value: 434.3e6
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    label: cutoff_freq
    start: '1'
    step: '1'
    stop: 100e5
    value: 10e3
  states: {}
- name: filter_decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: freq
    rangeType: int
    start: int(430e6)
    step: '1'
    stop: int(440e6)
    value: '433885000'
    widget: eng_slider
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: gain
    rangeType: int
    start: '-12'
    step: '1'
    stop: '64'
    value: '30'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbol_period
  id: variable
  parameters:
    value: '520e-6'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1/symbol_period
  states: {}
- name: threshold_high
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: threshold_high
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
    widget: eng_slider
  states: {}
- name: threshold_low
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: threshold_low
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
    widget: eng_slider
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.5'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq-freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/fifo
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/shared/gqrx_20230605_162229_434701600_2000000_fc.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: int((symbol_period*4)*(samp_rate/filter_decimation))
    offset: '0'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int((2080*10**-6)*(samp_rate/filter_decimation))
    max_iter: '4000'
    scale: 1/int((2080*10**-6)*(samp_rate/filter_decimation))
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '80'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: agc_off
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold_high
    init: '0'
    low: threshold_low
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.5'
    init: '0'
    low: '0.5'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: filter_decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    samp_per_symbol: int((samp_rate/filter_decimation) * symbol_period)
    size: 2**14
    srate: samp_rate/filter_decimation
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: cutoff_freq
    fc: freq
    fftsize: '1024'
    name: filtered
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: freq
    fftsize: '8192'
    name: shifted
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"threshold"'
    size: 2**14
    srate: samp_rate/filter_decimation
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"moving average"'
    size: 2**8
    srate: '480'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    name: magnitude
    size: int(2**14)
    srate: samp_rate/filter_decimation
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: filtered
    size: 2**14
    srate: samp_rate/filter_decimation
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"input"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"shifted"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: cutoff_freq
    fc: '0'
    fftsize: '1024'
    name: '"filtered"'
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_agc_xx_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_selector_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_eye_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_selector_0, '0', blocks_threshold_ff_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_threshold_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_throttle2_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
